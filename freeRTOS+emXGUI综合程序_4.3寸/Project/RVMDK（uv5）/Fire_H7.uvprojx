# Keil uVision project Fire_H7.uvprojx, settings and files
target Fire_H7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Fire_H7
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,X_GUI_USE_FREERTOS,Fire_H7_InFlash,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F7,NDEBUG,
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User;..\..\freeRTOS\include;..\..\freeRTOS\port\RVDS\ARM_CM7\r0p1;..\..\User\cm_backtrace;..\..\User\FATFS;..\..\emXGUI_Lib\arch\Inc;..\..\emXGUI_Lib\inc;..\..\emXGUI_Lib\drv;..\..\emXGUI_Lib\app\base;..\..\User\app\GUI_Demo;..\..\emXGUI_Lib\app\base\boot_interface;..\..\User\lib\libpng-1.6.34;..\..\User\lib\zlib-1.2.11;..\..\User\lib\app;..\..\User\app\Board_App\rgb_led;..\..\User\app\Board_App\rgb_led\OwnerDraw;..\..\User\app\Board_App\adc_Collect_voltage;..\..\User\app\Board_App;..\..\User\app\Board_App\clock\RTC;..\..\User\app\Board_App\gyro\mpu6050\driver\stm32L;..\..\User\app\Board_App\gyro\mpu6050\driver\eMPL;..\..\User\app\Board_App\gyro\mpu6050\driver\include;..\..\User\app\Board_App\gyro\mpu6050\eMPL-hal;..\..\User\app\Board_App\gyro\mpu6050\mllite;..\..\User\app\Board_App\gyro;..\..\User\app\Board_App\gyro\mpu6050\mpl;..\..\User\app\Board_App\Phone_SMS;..\..\User\app\Board_App\recorder;..\..\User\app\Board_App\recorder;..\..\User\app\Board_App\mp3_decoder;..\..\User\app\Board_App\mp3_decoder\pub;..\..\User\app\Board_App\mp3_decoder\real;..\..\User\app\Board_App\video_player;..\..\User\app\Board_App\camera;..\..\User\app\Board_App\camera\QR_Decoder;..\..\User\app\Board_App\NetworkDLG\arch;..\..\User\app\Board_App\NetworkDLG\bsp\LAN8720A;..\..\User\app\Board_App\NetworkDLG\Lwip;..\..\User\app\Board_App\NetworkDLG\lwipapp;..\..\User\app\Board_App\NetworkDLG;..\..\User\app\Board_App\NetworkDLG\Lwip\include;..\..\User\app\Board_App\NetworkDLG\Lwip\api;..\..\User\app\Board_App\NetworkDLG\Lwip\apps;..\..\User\app\Board_App\NetworkDLG\Lwip\core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\Output\Fire_H7.sct
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group STM32H7xx_HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group USER
    ../../User/: main.c stm32h7xx_it.c FreeRTOSConfig.h board.h
  group BSP
    ../../User/touch/: gt9xx.c bsp_i2c_touch.c
    ../../User/sd_card/: bsp_sdio_sd.c
    ../../User/delay/: core_delay.c
    ../../User/flash/: bsp_qspi_flash.c
    ../../User/lcd/: bsp_lcd.c
    ../../User/sdram/: bsp_sdram.c
    ../../User/usart/: bsp_usart.c
    ../../User/led/: bsp_led.c
    ../../User/mpu/: bsp_mpu.c
    ../../User/cpuusage/: cpuusage.c
    ../../User/beep/: bsp_beep.c
    ../../User/key/: bsp_key.c
    ../../User/wm8978/: bsp_wm8978.c
    ../../User/i2c/: i2c.c
    ../../User/app/Board_App/tim/: bsp_basic_tim.c
  group cm_backtrace
    ../../User/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../../User/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group Fafts
    ../../User/FATFS/: diskio.c ff.c ff_gen_drv.c
    ../../User/FATFS/option/: cc936.c syscall.c
    ../../User/FATFS/drivers/: fatfs_sd_sdio.c
  group freeRTOS/src
    ../../freeRTOS/src/: croutine.c event_groups.c list.c tasks.c queue.c timers.c
  group freeRTOS/port
    ../../freeRTOS/port/MemMang/: heap_4.c
    ../../freeRTOS/port/RVDS/ARM_CM7/r0p1/: port.c
  group emXGUI/arch
    ../../emXGUI_Lib/arch/: GUI_Arch.c GUI_GPU.c
    ../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
    ../../emXGUI_Lib/arch/Inc/: gui_drv.h gui_os_port.h
  group emXGUI/resource
    ../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_20_4BPP.c ASCII_24_4BPP.c GB2312_16_2BPP.c
  group emXGUI/drv
    ../../User/: gui_drv_cfg.h
    ../../emXGUI_Lib/drv/: gui_font_port.c gui_fs_port.c gui_input_port.c gui_lcd_port.c gui_log_port.c gui_mem_port.c gui_picture_port.c gui_resource_port.c gui_touch_port.c
  group emXGUI/inc
    ../../emXGUI_Lib/inc/: emXGUI.h Clist.h def.h emXGUI_Arch.h emXGUI_JPEG.h emxgui_png.h GUI_Font_XFT.h Web_Color.h x_libc.h x_obj.h
    ../../emXGUI_Lib/libs/: x_obj.cpp
  group emXGUI/libs
    ../../emXGUI_Lib/libs/: emXGUI100_MDK_M7.lib x_libc_MDK_M7.lib libjpeg_MDK_M7.lib libpng_MDK_M7.lib
  group emXGUI/res
    ../../emXGUI_Lib/app/base/boot_interface/: boot_logo.c
  group OEM_Face
    ../../emXGUI_Lib/OEM_Face/: OEM_Button.c OEM_CheckBox.c OEM_GroupBox.c OEM_ListBox.c OEM_ProgressBar.c OEM_RadioBox.c OEM_ScrollBar.c OEM_TextBox.c
  group boot_window
    ../../emXGUI_Lib/drv/: gui_startup.c
    ../../emXGUI_Lib/app/base/: gui_desktop.c GUI_AppDef.h
    ../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c
    ../../emXGUI_Lib/app/base/boot_interface/pic_load/: gui_pic_load.c
    ../../User/app/Board_App/: GUI_Board_App_Desktop.c
    ../../emXGUI_Lib/app/base/res_writer/: backend_res_writer.c GUI_RES_Writer_Dialog.c
    ../../User/app/GUI_Demo/: CListMenu.cpp
  group APP_GUI
    ../../User/app/GUI_Demo/: GUI_App_Desktop.c GUI_DEMO_SlideWindow.c calculator.cpp GUI_DEMO_AutoMeter.c GUI_DEMO_Button.c GUI_DEMO_Button_OwnerDraw.c GUI_DEMO_Checkbox.c GUI_DEMO_Graphics_Accelerator.c GUI_DEMO_Listbox.c GUI_DEMO_Messagebox.c GUI_DEMO_Number_Keyboard.c GUI_DEMO_Progressbar.c GUI_DEMO_RadiaMenu.c GUI_DEMO_Radiobox.c GUI_DEMO_Scrollbar.c GUI_DEMO_ShowWave.cpp GUI_DEMO_Textbox.c GUI_SelectDialogBox.c
    ../../User/app/Board_App/rgb_led/OwnerDraw/: Widget.c
  group tutorial/mp3
    ../../User/app/Board_App/mp3_player/: GUI_MUSICPLAYER_DIALOG.c GUI_MusicList_DIALOG.c Backend_mp3Player.c
  group tutorial/recorder
    ../../User/app/Board_App/recorder/: GUI_RECORDER_DIALOG.c Backend_Recorder.c
  group tutorial/bsp_mp3
    ../../User/app/Board_App/mp3_decoder/: mp3dec.c mp3tabs.c
    ../../User/app/Board_App/mp3_decoder/real/: assembly.h bitstream.c buffers.c coder.h dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../../User/app/Board_App/mp3_decoder/real/arm/: asmmisc.s asmpoly_thumb2.s
    ../../User/app/Board_App/mp3_decoder/pub/: mp3common.h mp3dec.h mpadecobjfixpt.h statname.h
  group tutorial/rgb_led
    ../../User/app/Board_App/rgb_led/: Backend_RGBLED.c GUI_RGBLED_DIALOG.c
  group tutorial/beep
    ../../User/app/Board_App/beeper_control/: GUI_Beeper_Dialog.c
  group tutorial/LED&KEY
    ../../User/app/Board_App/LED_Key/: GUI_LED_KEY_Dialog.c
  group tutorial/setting
    ../../User/app/Board_App/setting/: GUI_DEMO_Settings.c
  group tutorial/clock
    ../../User/app/Board_App/clock/: GUI_CLOCK_DIALOG.c
    ../../User/app/Board_App/clock/RTC/: bsp_rtc.c
  group tutorial/adc
    ../../User/app/Board_App/adc_Collect_voltage/: GUI_ADC_CollectVoltage_Dialog.c bsp_adc.c
  group tutorial/dth11
    ../../User/app/Board_App/T_RH/: GUI_T_RH_Dialog.c
    ../../User/app/Board_App/T_RH/dht11/: bsp_dht11.c
  group tutorial/pic_viwer
    ../../User/app/Board_App/pic_viewer/: GUI_PicViewr_Dialog.c
  group tutorial/PhoneCallMonitorTask
    ../../User/app/Board_App/Phone_SMS/: GUI_Phone_Dialog.c GUI_SMS_Dialog.c
    ../../User/app/Board_App/Phone_SMS/bsp_sim/: bsp_gsm_gprs.c bsp_gsm_usart.c
  group tutorial/gyro
    ../../User/app/Board_App/gyro/: GUI_Gyro_Dialog.c
    ../../User/app/Board_App/gyro/mpu6050/: bsp_mpu_exti.c
    ../../User/app/Board_App/gyro/i2c_for_mpu6050/: MPU6050_i2c.c
  group MPU_eMPL
    ../../User/app/Board_App/gyro/mpu6050/eMPL-hal/: eMPL_outputs.c
    ../../User/app/Board_App/gyro/mpu6050/driver/stm32L/: log_stm32.c
    ../../User/app/Board_App/gyro/mpu6050/driver/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
  group MPU_mllite
    ../../User/app/Board_App/gyro/mpu6050/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group MPU_mpl
    ../../User/app/Board_App/gyro/mpu6050/mpl/libmpllib_Keil_M4/: libmpllib.lib
  group tutorial/video_player
    ../../User/app/Board_App/video_player/: GUI_VEDIOPLAYER_DIALOG.c Backend_vidoplayer.c Backend_avifile.c
  group DOC
    ../../: 必读说明.txt
  group tutorial/camera
    ../../User/app/Board_App/camera/: bsp_ov5640.c bsp_ov5640_i2c.c GUI_Camera_Dialog.c GUI_Camera_QRCode_Dialog.c ov5640_AF.c
    ../../User/app/Board_App/camera/QR_Decoder/: QR_Core.lib
  group tutorial/lwip
    ../../User/app/Board_App/NetworkDLG/: GUI_Network_Dialog.c
    ../../User/app/Board_App/NetworkDLG/bsp/LAN8720A/: LAN8720A.c
  group LwIP/arch
    ../../User/app/Board_App/NetworkDLG/arch/: ethernetif.c sys_arch.c
  group LwIP/api
    ../../User/app/Board_App/NetworkDLG/LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ../../User/app/Board_App/NetworkDLG/LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../User/app/Board_App/NetworkDLG/LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ../../User/app/Board_App/NetworkDLG/LwIP/netif/: bridgeif.c ethernet.c lowpan6_ble.c lowpan6.c lowpan6_common.c zepif.c
  group LwIP/app
    ../../User/app/Board_App/NetworkDLG/lwipapp/: tcp_echoclient.c tcp_echoserver.c tcpecho.c udp_echoclient.c udp_echoserver.c
